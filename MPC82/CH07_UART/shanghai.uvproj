# Keil uVision project shanghai.uvproj, settings and files
target Target 1 (MCS-51)
  device: MG84FG516 Megawin
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) XRAM (0-0x13FF) CLOCK(32000000)
  output: midi
  c flags: SizeSpeed=1
  group Source Group 1
    ./: UART4 - 516.C
