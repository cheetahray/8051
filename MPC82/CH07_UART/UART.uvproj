# Keil uVision project UART.uvproj, settings and files
target Target 1 (MCS-51)
  device: MPC82G516 Megawin
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) XRAM (0-0x3FF) CLOCK(24000000)
  output: UART +hex
  c flags: SizeSpeed=1
  group Source Group 1
    ./: UART4 - Ray.C
